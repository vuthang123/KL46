# IAR project ledbinling.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: C:\Users\THANG\Dropbox\PC\Desktop\KL46_GIT\Create new project IAR\ledbinling\source; C:\Users\THANG\Dropbox\PC\Desktop\KL46_GIT\Create new project IAR\ledbinling\MKL46Z; C:\Users\THANG\Dropbox\PC\Desktop\KL46_GIT\Create new project IAR\ledbinling\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ledbinling.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main.c
  group Startup
    ../MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
